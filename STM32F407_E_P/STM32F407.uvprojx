# Keil uVision project STM32F407.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\SYSTEM\sys;.\SYSTEM\delay;.\CORE;.\USER;.\FWLIB\inc;.\HARDWARE\AT24C02;.\HARDWARE\LCD;.\HARDWARE\GPIO_Init;.\HARDWARE\AD9851;.\HARDWARE\X9C503;.\HARDWARE\DAC;.\HARDWARE\TFT_LCD;.\HARDWARE\PWM;.\HARDWARE\Logo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_fsmc.c
  group HardWare
    ./HARDWARE/AT24C02/: AT24C02.c
    ./HARDWARE/LCD/: LCD.c
    ./HARDWARE/GPIO_Init/: GPIO_Init.c
    ./HARDWARE/DAC/: DAC.c
    ./HARDWARE/TFT_LCD/: TFT_LCD.c
    ./HARDWARE/PWM/: bsp_tim_pwm.c
